# Keil uVision project ADTest.uvprojx, settings and files
target ADTest (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADTest
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F10x\Include;..\Firmware\GD32F10x_standard_peripheral\Include;..\Main;..\Drive
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Library
    ../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_dma.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c
    ../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group Main
    ../Main/: gd32f10x_it.c main.c systick.c timer.c
  group Driver
    ../Drive/: usart.c ms5148t.c
